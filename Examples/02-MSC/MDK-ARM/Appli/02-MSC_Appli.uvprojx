# Keil uVision project 02-MSC_Appli.uvprojx, settings and files
target 02-MSC_Appli (6210000::V6.21::ARMCLANG)
  device: STM32H7R3Z8Jx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: 02-MSC_Appli +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx
  c include: ../../Appli/Core/Inc;../../Appli/USB_DEVICE/App;../../Appli/USB_DEVICE/Target;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: stm32h7r3xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7r3xx.s
  group Application/User/Appli/USB_DEVICE/Target
    ../../Appli/USB_DEVICE/Target/: usbd_conf.c
  group Application/User/Appli/USB_DEVICE/App
    ../../Appli/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c gpio.c rtc.c sdmmc.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_usb.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c
  group Middlewares/STM32_USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
software components: CMSIS:CORE 4.3.0
