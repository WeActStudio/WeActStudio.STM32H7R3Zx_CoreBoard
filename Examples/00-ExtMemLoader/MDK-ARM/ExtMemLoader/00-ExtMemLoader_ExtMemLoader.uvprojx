# Keil uVision project 00-ExtMemLoader_ExtMemLoader.uvprojx, settings and files
target 00-ExtMemLoader_ExtMemLoader (6210000::V6.21::ARMCLANG)
  device: STM32H7R3Z8Jx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)             CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 00-ExtMemLoader_ExtMemLoader +hex
  AfterMake: cmd.exe /C copy "!L" "{STM32_PRG_PATH}\ExternalLoader\@L.stldr"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx,STM32_EXTMEMLOADER_STM32CUBETARGET
  c include: ../../ExtMemLoader/Core/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Middlewares/ST/STM32_ExtMem_Loader/core;../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM;../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube;../../Middlewares/ST/STM32_ExtMem_Manager;../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../Middlewares/ST/STM32_ExtMem_Manager/sdcard;../../Middlewares/ST/STM32_ExtMem_Manager/user;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include
  asm define: STM32_EXTMEMLOADER_STM32CUBETARGET
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: stm32h7rsxx_extmemloader_stm32cube.sct
  link misc: --diag_suppress L6312,L6314,L6244E
  group Application/User/ExtMemLoader/Core
    ../../ExtMemLoader/Core/Src/: gpio.c extmem_manager.c xspi.c stm32h7rsxx_hal_msp.c extmemloader_init.c
  group Drivers/CMSIS
    ../../ExtMemLoader/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
  group Middlewares/STM32_ExtMem_Loader
    ../../Middlewares/ST/STM32_ExtMem_Loader/core/: memory_wrapper.c systick_management.c
    ../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM/: FlashDev.c FlashPrg.c
    ../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube/: stm32_device_info.c stm32_loader_api.c
target 00-ExtMemLoader_ExtMemLoader_Keil (6210000::V6.21::ARMCLANG)
  device: STM32H7R3Z8Jx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)         CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 00-ExtMemLoader_ExtMemLoader_keil +hex
  AfterMake: cmd.exe /C copy "!L" ".\STM32H7R3Z8Jx_8MB_WeAct.FLM"
  c flags: Optim=7 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx,STM32_EXTMEMLOADER_MDKARMTARGET
  c include: as above
  asm define: STM32_EXTMEMLOADER_MDKARMTARGET
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: .\stm32h7rsxx_extmemloader_mdkarm.sct
  link misc: --diag_suppress L6312,L6314,L6244E
software components: CMSIS:CORE 4.3.0
